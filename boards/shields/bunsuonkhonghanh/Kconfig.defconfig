## boards/shields/bunsuonkhonghanh/Kconfig.shield
```kconfig
config SHIELD_BUNSUONKHONGHANH
    def_bool $(shields_list_contains,Bunsuonkhonghanh)
```
